# Keil uVision project base_project.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.4.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) XRAM(0x00000000,0x00080000) XRAM2(0x01000000,0x00100000) XRAM3(0x20000000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: base_project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-padded -Wno-covered-switch-default
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\linker_SSE300MPS3_secure.sct
  group Source Group 1
    ./: main.c
software components: CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.6.0, Device:Definition 2.0.0, Device:Native Driver:IO 1.1.0, Device:Native Driver:SysCounter 1.1.0, Device:Native Driver:SysTimer 1.1.0, Device:Native Driver:Timeout 1.0.0, Device:Native Driver:UART 1.1.0, Device:Startup 2.0.0, Device:USART STDOUT 1.0.0, Compiler:I/O:STDOUT 1.2.0
