# Keil uVision project object_classification.uvprojx, settings and files
target MobileNetV3 (6210000::V6.21::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.4.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) XRAM(0x00000000,0x00080000) XRAM2(0x01000000,0x00100000) XRAM3(0x20000000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: object_classification +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_MOBILENETV3
  c misc: -mthumb
  c include: .\cls\codegen\host\include;.\cls\runtime\include;.\include
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\sct\VHT_Corstone_SSE-300.sct
  group Source
    ./: main.c
  group Cls
    ./cls/codegen/host/src/: cls_lib0.c cls_lib1.c
    ./cls/runtime/src/runtime/crt/common/: crt_backend_api.c
target NewTarget (6210000::V6.21::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.4.0
  cpu: as above
  output: object_classification +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c misc: -Wl,--no-whole-archive -lm -specs=nosys.specs -static -T corstone300.ld
  c include: .\MobileNetV3_small_x0_35_ssld_infer\cls\codegen\host\include;.\MobileNetV3_small_x0_35_ssld_infer\cls\runtime\include;.\MobileNetV3_small_x0_35_ssld_infer\include
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\linker_SSE300MPS3_secure.sct
software components: CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0, CMSIS:NN Lib 4.1.0, Device:Definition 2.0.0, Device:Native Driver:IO 1.1.0, Device:Native Driver:SysCounter 1.1.0, Device:Native Driver:SysTimer 1.1.0, Device:Native Driver:Timeout 1.0.0, Device:Native Driver:UART 1.1.0, Device:Startup 2.0.0, Device:USART STDOUT 1.0.0, Compiler:I/O:STDOUT 1.2.0
